FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://config.txt"

